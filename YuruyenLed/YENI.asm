	LIST		p=16f877A 
	INCLUDE 	<p16f877A.inc> 

SAYAC0 EQU 20H
B0	   EQU 21H
B1	   EQU 22H
B2	   EQU 23H

	ORG 	0x00
	GOTO 	BASLA

BASLA
	BANKSEL TRISB
	CLRF 	TRISB
	BANKSEL PORTB
	MOVLW 	b'00000001'
	MOVWF 	PORTB 
	
DONGU  
	CALL 	GECIKME
	RLF		PORTB,1
	GOTO 	DONGU 
		
GECIKME		 
	MOVLW		D'10'
	MOVWF		B2
	GOTO		DONGU1 
DONGU1		 
	MOVLW		D'180' 
	MOVWF		B0
	GOTO		DONGU2 
DONGU2
	MOVLW		D'50'
	MOVWF		B1
	GOTO		DONGU3 
DONGU3
	DECFSZ		B1,F
	GOTO		DONGU3 
	DECFSZ		B0,F
	GOTO		DONGU2
	DECFSZ		B2,F
	GOTO		DONGU1
	RETURN


	END
